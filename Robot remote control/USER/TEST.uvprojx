# Keil uVision project TEST.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: TEST
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD,MPL_LOG_NDEBUG=1,EMPL,EMPL_TARGET_STM32F10x
  c include: ..\HARDWARE\LED;..\HARDWARE\MPU6050;..\HARDWARE\SW;..\HARDWARE\KEY;..\HARDWARE\NRF24L01;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\sys;..\MY_C;..\STM32F10x_StdPeriph_Driver\inc;..\CMSIS\CM3\CoreSupport;..\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\HARDWARE\MPU9150\MPU6050_LIB\driver\eMPL;..\HARDWARE\MPU9150\MPU6050_LIB\driver\include;..\HARDWARE\MPU9150\MPU6050_LIB\driver\stm32L;..\HARDWARE\MPU9150\MPU6050_LIB\mllite;..\HARDWARE\MPU9150\MPU6050_LIB\mpl;..\HARDWARE\MPU9150\MPU6050_LIB\eMPL-hal;..\Peripheral_MY;..\Arithmetic
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source Group 1
    ../CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
    ../CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_md.s
  group USER
    ../MY_C/: test.c main_PID_steady_voltage_source.c main_calman_test.c main_Low_power_test.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/: stm32f10x_it.c
  group HARDWARE
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/LED/: led.c
  group MPU6050_DMP
    ../HARDWARE/MPU6050/: inv_mpu.c mpu6050.c inv_mpu_dmp_motion_driver.c
  group MPU9150_DMP
    ../HARDWARE/MPU9150/: MPU9150.c
    ../HARDWARE/MPU9150/MPU6050_LIB/driver/eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c
    ../HARDWARE/MPU9150/MPU6050_LIB/eMPL-hal/: eMPL_outputs.c
    ../HARDWARE/MPU9150/MPU6050_LIB/mllite/: data_builder.c hal_outputs.c message_layer.c ml_math_func.c mlmath.c mpl.c results_holder.c start_manager.c storage_manager.c
    ../HARDWARE/MPU9150/MPU6050_LIB/driver/stm32L/: log_stm32.c
    ../HARDWARE/MPU9150/MPU6050_LIB/mpl/: libmpllib.lib
  group MY_C
    ../MY_C/: outputdata.c
  group NRF24l01
    ../HARDWARE/NRF24L01/: nrf24l01.c
  group STM32F10x_StdPeriph_Driver
    ../CMSIS/CM3/CoreSupport/: core_cm3.c
    ../STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_wwdg.c stm32f10x_rcc.c stm32f10x_dma.c stm32f10x_gpio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_pwr.c
  group Peripheral
    ../Peripheral_MY/: exti.c myiic.c timer.c myspi.c usart.c ADC_KU.C Low_power.c
  group Arithmetic
    ../Arithmetic/: atan2.c PID.c kalman_MY.c
