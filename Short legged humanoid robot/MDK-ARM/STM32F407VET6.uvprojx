# Keil uVision project STM32F407VET6.uvprojx, settings and files
target STM32F407VET6 (ARM-ADS)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.5.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: STM32F407VET6 Configuration
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx,KEIL,DEBUG
  c misc: --C99
  c include: ../Inc;                             ../Drivers/STM32F4xx_HAL_Driver/Inc;                             ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;                             ../Drivers/CMSIS/Include;                             ../Drivers/CMSIS/Device/ST/STM32F4xx/Include;                             ..\MY_C\Arithmetic;                             ..\MY_C\delay;                             ..\MY_C\HARDWARE\NRF24L01;                             ..\MY_C\Peripheral_MY;                             ..\MY_C
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --diag_suppress=L6329
  group NRF24L01
    ../MY_C/HARDWARE/NRF24L01/: nrf24l01.c nrf24l01_2.c
  group MY_C
    ../MY_C/delay/: delay.c
    ../MY_C/: MAIN_MY.c outputdata.c
    ../MY_C/Arithmetic/: atan2.c Attitude.c PID.c
    ../MY_C/Peripheral_MY/: usart.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_dma_ex.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_spi.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_flash.c stm32f4xx_hal_pwr.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_dma.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_uart.c
  group Application/User
    ../Src/: main.c stm32f4xx_hal_msp.c stm32f4xx_it.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
software components: CMSIS:CORE 4.1.0
